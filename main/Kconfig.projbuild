## main/Kconfig.projbuild
```kconfig
config ADSB_HELTEC_V3
    bool "Build for the Heltec WiFi LoRa 32 V3 (SX1262)"
    default n
```
